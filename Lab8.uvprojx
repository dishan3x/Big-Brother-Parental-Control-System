# Keil uVision project Lab8.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TestJSON1
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx HSE_VALUE=8000000
  c include: .\STM32F4xx_StdPeriph_Driver\inc;.\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Files
    ./src/: main.c LED.c USART.c circularBuffer.c
    ./support/: system_stm32f4xx.c
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_syscfg.c
    ./STM32F4xx_StdPeriph_Driver/inc/: attributes.h tm_stm32f4_gpio.h
  group Flash OPT
    ./support/: STM32F40xxx_41xxx_OPT.s
  group StartUp
    ./support/: startup_stm32f40_41xxx.s
software components: CMSIS:CORE 5.0.1, Data Exchange:JSON:Jansson 2.7.0
